# Keil uVision project flash_algorithm.uvprojx, settings and files
target flash_algorithm (6220000::V6.22::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: Algorithm +hex
  AfterMake: cmd.exe /C copy "Objects\%L" ".\WIN04_Flash_Algorithm.FLM"
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: WIN04
  c include: ..\..\..\source\device\ARMCM0plus\Include;..\..\..\source\device\CMSIS_Core\Include;..\..\..\source\device\reg_device;..\..\..\source\component\error_def;..\..\..\source\component\utility;..\..\..\source\drivers\win04\register;..\..\..\source\drivers\win04\hw_rom\inc;..\..\..\source\mem_cfg\flash;..\..\..\source\mem_cfg\win04;..\..\..\source\device\win04;..\..\..\source\project_source\library\bootloader;.\config
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group drivers
    ../../../source/drivers/win04/hw_rom/src/: hw_sysctrl.c hw_gpio.c hw_flash.c hw_uart.c
  group components
    ../../../source/component/debug/: debug.c
    ../../../source/component/utility/: utility.c utility.s
  group main
    ../src/main/: flash_prog.c FlashDev.c

# Keil uVision project rf_test.uvprojx, settings and files
target rf_test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: rf_test +hex
  BeforeMake: ..\..\tools\adapt_for_v5\adapt_for_v5.bat $Prf_test.sct
  AfterMake: ..\..\tools\format_firmware\project_maker.bat "!L" "$KARM\ARMCC\bin\fromelf.exe"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: WIN04 CAD SLC_FPGA
  c include: ..\..\source\device\ARMCM0plus\Include;..\..\source\device\CMSIS_Core\Include;..\..\source\device\reg_device;..\..\source\component\error_def;..\..\source\component\utility;..\..\source\component\debug;..\..\source\drivers\win04\register;..\..\source\drivers\win04\hw_rom\inc;..\..\source\drivers\win04\hw_flash\inc;..\..\source\hal\inc;..\..\source\mem_cfg\flash;..\..\source\mem_cfg\win04;..\..\source\device\win04;.\config;..\..\source\drivers\win04\patch\inc;..\..\source\component\private_spi
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\rf_test_v5.sct
  link misc: --entry=Reset_Handler --keep=gstAppVersion --keep=gau8Boot2Code --diag_suppress=6314
  group startup
    ../../source/device/ARMCM0plus/Source/: startup_ARMCM0plus.s system_ARMCM0plus.c
  group lib
    ../../library/: boot2.c win04_rom_lib.lib
    ../../source/device/win04/: version.c
  group debug
    ../../source/component/debug/: debug.c
  group main
    ./: main.c
  group app
    ../../source/project_source/rf_test/: rf_test_main.c rf_test_interface.c
    ../../source/component/private_spi/: slc_private_spi_frame.c
  group drivers
    ../../source/drivers/win04/hw_flash/src/: slc_cali.c slc_phy.c slc_rf.c
    ../../source/drivers/win04/patch/src/: slc_intc.c
  group hal
    ../../source/hal/src/: slc_hal_intc.c slc_hal_sysctrl.c slc_hal_gpio.c slc_hal_uart.c slc_hal_pmu.c slc_hal_dma.c slc_hal_spi.c

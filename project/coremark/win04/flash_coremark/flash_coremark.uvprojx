# Keil uVision project flash_coremark.uvprojx, settings and files
target flash_coremark (6220000::V6.22::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: flash_coremark +hex
  AfterMake: ..\..\..\..\tools\format_firmware\project_maker.bat "!L" "$KARM\ARMCLANG\bin\fromelf.exe"
  c flags: Optim=8 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: WIN04 PERFORMANCE_RUN Coremark
  c include: ..\..\..\..\source\device\ARMCM0plus\Include;..\..\..\..\source\device\CMSIS_Core\Include;..\..\..\..\source\device\reg_device;..\..\..\..\source\device\win04;..\..\..\..\source\component\error_def;..\..\..\..\source\component\utility;..\..\..\..\source\drivers\win04\register;..\..\..\..\source\drivers\win04\hw_rom\inc;..\..\..\..\source\drivers\win04\hw_flash\inc;..\..\..\..\source\mem_cfg\flash;..\..\..\..\source\mem_cfg\win04;.\config;..\..\..\..\third_party\CoreMark\simple;..\..\..\..\third_party\CoreMark\;..\..\..\..\source\component\debug;..\..\..\..\source\hal\inc;..\..\..\..\source\drivers\win04\patch\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x80000000 size 0xf0000
  scatter file: .\flash_coremark.sct
  link misc: --entry=Reset_Handler --keep=gau8Boot2Code --keep=gstAppVersion --diag_suppress=6314 --diag_suppress=6329
  group startup
    ../../../../source/device/ARMCM0plus/Source/: system_ARMCM0plus.c startup_ARMCM0plus.s
  group lib
    ../../../../library/: boot2.c win04_rom_lib.lib
  group debug
    ../../../../source/component/debug/: debug.c
  group main
    ./: main.c
    ../../../../source/device/win04/: version.c
  group Coremark
    ../../../../third_party/CoreMark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c coremark.h
    ../../../../third_party/CoreMark/simple/: core_portme_win04.c core_portme.h
  group drivers
    ../../../../source/drivers/win04/hw_flash/src/: qmx_intc.c qmx_cali.c qmx_rf.c qmx_phy.c
    ../../../../source/drivers/win04/patch/src/: qmx_gpio.c qmx_dma.c qmx_uart.c qmx_pmu.c qmx_sysctrl.c
  group hal
    ../../../../source/hal/src/: qmx_hal_intc.c qmx_hal_sysctrl.c qmx_hal_gpio.c qmx_hal_uart.c qmx_hal_pmu.c qmx_hal_dma.c

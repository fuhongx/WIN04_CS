# Keil uVision project soc_test.uvprojx, settings and files
target soc_test (6190000::V6.19::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: soc_test +hex
  AfterMake: ..\..\..\tools\format_firmware\project_maker.bat "!L" "$KARM\ARMCLANG\bin\fromelf.exe"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: WIN04,SLC_SOCTEST,NT_SHELL,SLC_FPGA
  c include: ..\..\..\source\device\ARMCM0plus\Include;..\..\..\source\device\CMSIS_Core\Include;..\..\..\source\device\reg_device;..\..\..\source\device\win04;..\..\..\source\component\error_def;..\..\..\source\component\utility;..\..\..\source\component\debug;..\..\..\source\component\nt_shell\core\inc;..\..\..\source\component\nt_shell\util\inc;..\..\..\source\component\nt_shell;..\..\..\source\component\private_spi;..\..\..\source\drivers\win04\register;..\..\..\source\drivers\win04\hw_rom\inc;..\..\..\source\drivers\win04\hw_flash\inc;..\..\..\source\drivers\win04\patch\inc;..\..\..\source\mem_cfg\flash;..\..\..\source\mem_cfg\win04;..\..\..\source\hal\inc;.\config;..\..\..\source\component\crypto\aes;..\..\..\source\component\crypto\crc;..\..\..\source\project_source\soc_test\lowpower;..\..\..\source\project_source\soc_test\algo;..\..\..\source\project_source\soc_test\DMA;..\..\..\source\project_source\soc_test\flash;..\..\..\source\project_source\soc_test\IIC;..\..\..\source\project_source\soc_test\IWDT;..\..\..\source\project_source\soc_test\mem;..\..\..\source\project_source\soc_test\NVIC;..\..\..\source\project_source\soc_test\phy;..\..\..\source\project_source\soc_test\RTC;..\..\..\source\project_source\soc_test\soc_test;..\..\..\source\project_source\soc_test\systick;..\..\..\source\project_source\soc_test\timer;..\..\..\source\project_source\soc_test\WDT;..\..\..\source\project_source\soc_test\uart;..\..\..\source\project_source\soc_test\gpio;..\..\..\source\project_source\soc_test\lpio;..\..\..\source\project_source\soc_test\lpuart;..\..\..\source\project_source\soc_test\spi;..\..\..\source\component\crypto\hash;..\..\..\source\project_source\soc_test\reset;..\..\..\source\project_source\soc_test\cache
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x80000000 size 0xf0000
  scatter file: .\soc_test.sct
  link misc: --entry=Reset_Handler --keep=gstAppVersion --keep=gau8Boot2Code --diag_suppress=6314 --diag_suppress=6329 --datacompressor=off
  group startup
    ../../../source/device/ARMCM0plus/Source/: startup_ARMCM0plus.s system_ARMCM0plus.c
  group lib
    ../../../library/: boot2.c win04_rom_lib.lib
  group component
    ../../../source/component/debug/: debug.c
    ../../../source/component/private_spi/: slc_private_spi_frame.c
    ../../../source/component/crypto/crc/: sw_crc.c
    ../../../source/component/crypto/aes/: sw_aes.c
  group drivers
    ../../../source/drivers/win04/hw_flash/src/: slc_cali.c slc_lpwr_ctrl.c slc_rf.c slc_phy.c slc_afc.c slc_cad.c slc_debug_ila.c slc_phy_trx.c slc_sf_search.c slc_subg.c
    ../../../source/drivers/win04/hw_rom/src/: hw_systick.c
  group soc_test
    ../../../source/project_source/soc_test/algo/: slc_aes_test.c slc_rng_test.c slc_crc_test.c
    ../../../source/project_source/soc_test/DMA/: slc_dma_test.c
    ../../../source/project_source/soc_test/flash/: slc_flash_test.c
    ../../../source/project_source/soc_test/gpio/: slc_gpio_test.c
    ../../../source/project_source/soc_test/IIC/: slc_iic_test.c
    ../../../source/project_source/soc_test/IWDT/: slc_iwdt_test.c
    ../../../source/project_source/soc_test/lowpower/: slc_low_power_test.c
    ../../../source/project_source/soc_test/lpio/: slc_lpio_test.c
    ../../../source/project_source/soc_test/lpuart/: slc_lpuart_test.c
    ../../../source/project_source/soc_test/mem/: slc_mem_test.c
    ../../../source/project_source/soc_test/NVIC/: slc_nvic_test.c
    ../../../source/project_source/soc_test/phy/: slc_phy_test.c
    ../../../source/project_source/soc_test/RTC/: slc_rtc_test.c
    ../../../source/project_source/soc_test/soc_test/: slc_soc_test.c slc_test_master.c slc_test_master_slave_common.c slc_test_slave.c slc_uart_cmd_process.c
    ../../../source/project_source/soc_test/spi/: slc_spi_test.c
    ../../../source/project_source/soc_test/systick/: slc_systick_test.c
    ../../../source/project_source/soc_test/timer/: slc_pwm_test.c slc_timer_test.c
    ../../../source/project_source/soc_test/uart/: slc_uart_test.c
    ../../../source/project_source/soc_test/WDT/: slc_wdt_test.c
    ../../../source/project_source/soc_test/cache/: slc_cache_test.c
    ../../../source/project_source/soc_test/reset/: slc_reset_test.c
  group main
    ./: main.c
  group patch
    ../../../source/drivers/win04/patch/src/: slc_intc.c
  group nt_shell
    ../../../source/component/nt_shell/: nttop.c
    ../../../source/component/nt_shell/core/src/: ntlibc.c ntshell.c text_editor.c text_history.c vtrecv.c vtsend.c
    ../../../source/component/nt_shell/util/src/: ntopt.c ntstdio.c
  group version
    ../../../source/device/win04/: version.c
  group hal
    ../../../source/hal/src/: slc_hal_intc.c slc_hal_sysctrl.c slc_hal_gpio.c slc_hal_uart.c slc_hal_pmu.c slc_hal_rng.c slc_hal_crc.c slc_hal_dma.c slc_hal_spi.c slc_hal_timer.c slc_hal_aes.c slc_hal_iic.c slc_hal_iwdt.c slc_hal_lptimer.c slc_hal_lpuart.c slc_hal_pwm.c slc_hal_rtc.c slc_hal_wdt.c
target phy_test (6220000::V6.22::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: soc_test +hex
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: WIN04,NT_SHELL,SLC_PHYTEST,SLC_ILATEST,SLC_FPGA
  c misc: -Wno-empty-body
  c include: .\config;..\..\..\library;..\..\..\source\device\ARMCM0plus\Include;..\..\..\source\device\CMSIS_Core\Include;..\..\..\source\device\reg_device;..\..\..\source\device\win04;..\..\..\source\mem_cfg\flash;..\..\..\source\mem_cfg\win04;..\..\..\source\component\error_def;..\..\..\source\component\utility;..\..\..\source\component\debug;..\..\..\source\component\private_spi;..\..\..\source\drivers\win04\register;..\..\..\source\drivers\win04\hw_rom\inc;..\..\..\source\drivers\win04\hw_flash\inc;..\..\..\source\drivers\win04\patch\inc;..\..\..\source\hal\inc;..\..\..\source\component\nt_shell\core\inc;..\..\..\source\component\nt_shell\util\inc;..\..\..\source\component\nt_shell;..\..\..\source\project_source\soc_test\algo;..\..\..\source\project_source\soc_test\DMA;..\..\..\source\project_source\soc_test\flash;..\..\..\source\project_source\soc_test\IIC;..\..\..\source\project_source\soc_test\IWDT;..\..\..\source\project_source\soc_test\lowpower;..\..\..\source\project_source\soc_test\mem;..\..\..\source\project_source\soc_test\NVIC;..\..\..\source\project_source\soc_test\phy;..\..\..\source\project_source\soc_test\RTC;..\..\..\source\project_source\soc_test\soc_test;..\..\..\source\project_source\soc_test\systick;..\..\..\source\project_source\soc_test\timer;..\..\..\source\project_source\soc_test\WDT;..\..\..\source\project_source\soc_test\gpio;..\..\..\source\component\crypto\aes;..\..\..\source\component\crypto\crc;..\..\..\source\project_source\soc_test\uart;..\..\..\source\project_source\soc_test\gpio;..\..\..\source\project_source\soc_test\lpio;..\..\..\source\project_source\soc_test\lpuart;..\..\..\source\project_source\soc_test\spi
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0xf000
  memory RVCT10: RAM 0x80000000 size 0x40000
  scatter file: .\soc_test.sct
  link misc: --entry=Reset_Handler --keep=gstAppVersion --keep=gau8Boot2Code --diag_suppress=6314 --diag_suppress=6329
target autotest (6220000::V6.22::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: soc_test +hex
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: WIN04,SLC_AUTOTEST
  c misc: -Wno-empty-body
  c include: .\config;..\..\..\library;..\..\..\source\device\ARMCM0plus\Include;..\..\..\source\device\CMSIS_Core\Include;..\..\..\source\device\reg_device;..\..\..\source\component\error_def;..\..\..\source\component\utility;..\..\..\source\component\private_spi;..\..\..\source\device\win04;..\..\..\source\mem_cfg\flash;..\..\..\source\mem_cfg\win04;..\..\..\source\component\debug;..\..\..\source\drivers\win04\register;..\..\..\source\drivers\win04\patch\inc;..\..\..\source\drivers\win04\hw_flash\inc;..\..\..\source\drivers\win04\hw_rom\inc;..\..\..\source\hal\inc;..\..\..\source\component\nt_shell\core\inc;..\..\..\source\component\nt_shell\util\inc;..\..\..\source\component\nt_shell;..\..\..\source\project_source\soc_test\algo;..\..\..\source\project_source\soc_test\DMA;..\..\..\source\project_source\soc_test\flash;..\..\..\source\project_source\soc_test\IIC;..\..\..\source\project_source\soc_test\IWDT;..\..\..\source\project_source\soc_test\lowpower;..\..\..\source\project_source\soc_test\mem;..\..\..\source\project_source\soc_test\NVIC;..\..\..\source\project_source\soc_test\phy;..\..\..\source\project_source\soc_test\RTC;..\..\..\source\project_source\soc_test\soc_test;..\..\..\source\project_source\soc_test\systick;..\..\..\source\project_source\soc_test\timer;..\..\..\source\project_source\soc_test\WDT;..\..\..\source\component\crypto\aes;..\..\..\source\component\crypto\crc;..\..\..\source\project_source\soc_test\uart
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x80000000 size 0xf0000
  scatter file: .\soc_test.sct
  link misc: as above
target mini_test (6220000::V6.22::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: soc_test +hex
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: WIN04,NT_SHELL,SLC_FPGA
  c include: ..\..\..\source\device\ARMCM0plus\Include;..\..\..\source\device\CMSIS_Core\Include;..\..\..\source\device\reg_device;..\..\..\source\device\win04;..\..\..\source\component\error_def;..\..\..\source\component\utility;..\..\..\source\component\debug;..\..\..\source\component\nt_shell\core\inc;..\..\..\source\component\nt_shell\util\inc;..\..\..\source\component\nt_shell;..\..\..\source\component\private_spi;..\..\..\source\drivers\win04\register;..\..\..\source\drivers\win04\hw_rom\inc;..\..\..\source\drivers\win04\hw_flash\inc;..\..\..\source\drivers\win04\patch\inc;..\..\..\source\mem_cfg\flash;..\..\..\source\mem_cfg\win04;..\..\..\source\hal\inc;.\config;..\..\..\source\component\crypto\aes;..\..\..\source\component\crypto\crc;..\..\..\source\project_source\soc_test\lowpower;..\..\..\source\project_source\soc_test\algo;..\..\..\source\project_source\soc_test\DMA;..\..\..\source\project_source\soc_test\flash;..\..\..\source\project_source\soc_test\IIC;..\..\..\source\project_source\soc_test\IWDT;..\..\..\source\project_source\soc_test\mem;..\..\..\source\project_source\soc_test\NVIC;..\..\..\source\project_source\soc_test\phy;..\..\..\source\project_source\soc_test\RTC;..\..\..\source\project_source\soc_test\soc_test;..\..\..\source\project_source\soc_test\systick;..\..\..\source\project_source\soc_test\timer;..\..\..\source\project_source\soc_test\WDT;..\..\..\source\project_source\soc_test\uart;..\..\..\source\project_source\soc_test\gpio;..\..\..\source\project_source\soc_test\lpio;..\..\..\source\project_source\soc_test\lpuart;..\..\..\source\project_source\soc_test\spi;..\..\..\source\component\crypto\hash
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x80000000 size 0xf0000
  scatter file: .\soc_test.sct
  link misc: as above

# Keil uVision project Boot2.uvprojx, settings and files
target boot2 (6220000::V6.22::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: boot2 +hex
  AfterMake: ..\..\..\..\tools\format_boot2\format_boot2.bat "!L" "$KARM\ARMCLANG\bin\fromelf.exe"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: WIN04 BOOT2PROJECT
  c include: ..\..\..\..\source\device\ARMCM0plus\Include;..\..\..\..\source\device\CMSIS_Core\Include;..\..\..\..\source\device\reg_device;..\..\..\..\source\component\error_def;..\..\..\..\source\component\utility;..\..\..\..\source\drivers\win04\register;..\..\..\..\source\drivers\win04\hw_rom\inc;..\..\..\..\source\mem_cfg\flash;..\..\..\..\source\mem_cfg\win04;..\..\..\..\source\device\win04;.\config;..\..\..\..\source\project_source\library\boot2;..\..\..\..\source\project_source\library\debug;..\..\..\..\source\component\crypto\ecc;..\..\..\..\source\component\crypto\hash
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\boot2.sct
  link misc: --entry=boot2_main --keep=gstBoot2Version --diag_suppress=6314
  group driver
    ../../../../library/: win04_rom_lib.lib
  group component
    ../../../../source/project_source/library/debug/: debug.c
  group boot
    ../../../../source/project_source/library/boot2/: boot2_main.c boot_upgrade.c
  group version
    ../../../../source/device/win04/: version.c

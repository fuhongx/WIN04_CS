# Keil uVision project rom_lib.uvprojx, settings and files
target rom_lib (6220000::V6.22::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: rom_lib +hex
  AfterMake: .\rom_lib.bat "!L" "$KARM\ARMCLANG\bin\fromelf.exe"
  AfterMake: fromelf.exe --bin -o ./Objects/rom_lib.bin ./Objects/rom_lib.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: WIN04,ROM_LIB_PROJECT
  c include: ..\..\..\..\source\device\ARMCM0plus\Include;..\..\..\..\source\device\CMSIS_Core\Include;..\..\..\..\source\device\reg_device;..\..\..\..\source\component\error_def;..\..\..\..\source\component\utility;..\..\..\..\source\drivers\win04\register;..\..\..\..\source\drivers\win04\hw_rom\inc;..\..\..\..\source\mem_cfg\flash;..\..\..\..\source\mem_cfg\win04;..\..\..\..\source\device\win04;.\config;..\..\..\..\source\project_source\library\debug;..\..\..\..\source\project_source\library\bootloader;..\..\..\..\source\component\crypto\ecc;..\..\..\..\source\component\crypto\hash
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x8000000 size 0x1f000
  scatter file: .\rom_lib.sct
  link misc: --symdefs=rom_lib.lib --no_remove --keep=* --diag_suppress=6314
  group startup
    ./startup/: startup_ARMCM0plus.s system_ARMCM0plus.c
  group driver
    ../../../../source/drivers/win04/hw_rom/src/: hw_flash.c hw_gpio.c hw_uart.c hw_sysctrl.c hw_crc.c hw_pmu.c hw_rng.c hw_aes.c hw_dma.c hw_iic.c hw_lpuart.c hw_rtc.c hw_spi.c hw_timer.c hw_wdt.c hw_systick.c
  group component
    ../../../../source/component/utility/: utility.c delay_nop_asm.s
    ../../../../source/project_source/library/debug/: debug.c
    ../../../../source/component/crypto/ecc/: uECC.c
    ../../../../source/component/crypto/hash/: sha256.c
  group boot
    ../../../../source/project_source/library/bootloader/: boot_interface.c bootloader.c firmware_upgrade.c
    ./: boot_main.c
